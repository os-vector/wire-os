CACHED_CONFIGUREVARS:append:class-target = " libc_cv_gcc_has_64b_atomics=no"
